Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T09:35:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 09:35:33 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{558C2BA0-E084-42AB-92A8-4AC291FCEFA1}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 09:35:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 09:35:33 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 09:35:33 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26721010_D_11022850_KM7210FR, 11022850_D_KM7210FR:26721010_D_11022850_KM7210FR:205538
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 26721010_D_11022850_KM7210FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
